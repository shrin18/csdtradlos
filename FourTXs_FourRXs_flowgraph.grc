<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qt_cdma_txrx</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>qt_cdma_txrx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est_1</value></param>
<param><key>value</key><value>EsN0dB_est_1+ 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est_2</value></param>
<param><key>value</key><value>EsN0dB_est_2 + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est_3</value></param>
<param><key>value</key><value>EsN0dB_est_3 + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est_4</value></param>
<param><key>value</key><value>EsN0dB_est_4 + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated_1</value></param>
<param><key>value</key><value>DataEsN0dB_est_1</value></param>
<param><key>gui_hint</key><value>9,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dB_est_1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated_2</value></param>
<param><key>value</key><value>DataEsN0dB_est_2</value></param>
<param><key>gui_hint</key><value>17,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dB_est_2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated_3</value></param>
<param><key>value</key><value>DataEsN0dB_est_3</value></param>
<param><key>gui_hint</key><value>21,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dB_est_3</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated_4</value></param>
<param><key>value</key><value>DataEsN0dB_est_4</value></param>
<param><key>gui_hint</key><value>23,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dB_est_4</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DataEsN0dBthreshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>5,0,1,3</value></param>
<param><key>label</key><value>DataEsN0dBthreshold</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EsN0dB</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>EsN0dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est_1</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest_1)/ (abs(N0est_1)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est_2</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest_2)/ (abs(N0est_2)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est_3</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest_3)/ (abs(N0est_3)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est_4</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest_4)/ (abs(N0est_4)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest_1</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp_1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest_2</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp_2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest_3</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp_3</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest_4</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp_4</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N0</value></param>
<param><key>value</key><value>10**(-EsN0dB/10) * Es</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est_1</value></param>
<param><key>block_id</key><value>blocks_probe_signal_1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est_2</value></param>
<param><key>block_id</key><value>blocks_probe_signal_2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est_3</value></param>
<param><key>block_id</key><value>blocks_probe_signal_3</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est_4</value></param>
<param><key>block_id</key><value>blocks_probe_signal_4</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB_1</value></param>
<param><key>value</key><value>TrainingEsN0dB_est_1</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>label</key><value>TrainingEsN0dB_est_1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB_2</value></param>
<param><key>value</key><value>TrainingEsN0dB_est_2</value></param>
<param><key>gui_hint</key><value>16,0,1,2</value></param>
<param><key>label</key><value>TrainingEsN0dB_est_2</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB_3</value></param>
<param><key>value</key><value>TrainingEsN0dB_est_3</value></param>
<param><key>gui_hint</key><value>20,0,1,2</value></param>
<param><key>label</key><value>TrainingEsN0dB_est_3</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB_4</value></param>
<param><key>value</key><value>TrainingEsN0dB_est_4</value></param>
<param><key>gui_hint</key><value>22,0,1,2</value></param>
<param><key>label</key><value>TrainingEsN0dB_est_4</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est_1</value></param>
<param><key>value</key><value>EsN0dB_est_1+ 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est_2</value></param>
<param><key>value</key><value>EsN0dB_est_2 + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est_3</value></param>
<param><key>value</key><value>EsN0dB_est_3 + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est_4</value></param>
<param><key>value</key><value>EsN0dB_est_4 + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>gui_hint</key><value>4,0,1,3</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cp.chips_per_symbol</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,3</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>99</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>cp.df*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>df_Hz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label</key><value>df_Hz</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(cp.freqs[0]*samp_rate)-1e-6</value></param>
<param><key>step</key><value>(cp.freqs[-1]-cp.freqs[0])*samp_rate/1000</value></param>
<param><key>stop</key><value>cp.freqs[-1]*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>dft</value></param>
<param><key>value</key><value>df</value></param>
<param><key>gui_hint</key><value>6,2,1,1</value></param>
<param><key>label</key><value>Deltaf (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>fmaxt</value></param>
<param><key>value</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>gui_hint</key><value>6,1,1,1</value></param>
<param><key>label</key><value>f_max (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est_1</value></param>
<param><key>block_id</key><value>blocks_probe_freq_1</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est_2</value></param>
<param><key>block_id</key><value>blocks_probe_freq_2</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est_3</value></param>
<param><key>block_id</key><value>blocks_probe_freq_3</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est_4</value></param>
<param><key>block_id</key><value>blocks_probe_freq_4</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq_1</value></param>
<param><key>value</key><value>freq_acq_est_1</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq_2</value></param>
<param><key>value</key><value>freq_acq_est_2</value></param>
<param><key>gui_hint</key><value>18,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq_3</value></param>
<param><key>value</key><value>freq_acq_est_3</value></param>
<param><key>gui_hint</key><value>19,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq_4</value></param>
<param><key>value</key><value>freq_acq_est_4</value></param>
<param><key>gui_hint</key><value>24,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label0</key><value>'Auto'</value></param>
<param><key>label1</key><value>'Manual'</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>n_filt</value></param>
<param><key>value</key><value>cp.n_filt</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label</key><value>n_filt</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_0</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_0_0</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_0_0_0</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est_1&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto_0</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est_2&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto_0_0</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est_3&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto_0_0_0</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est_3&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label0</key><value>'Tracking'</value></param>
<param><key>label1</key><value>'Acquisition'</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>map(int,numpy.random.randint(0,256,payload_bytes_per_frame))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_bytes_per_frame</value></param>
<param><key>value</key><value>cp.payload_bytes_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_static_text</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blks2_error_rate</key>
<param><key>id</key><value>blks2_error_rate_0</value></param>
<param><key>bits_per_symbol</key><value>8</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>'SER'</value></param>
<param><key>win_size</key><value>10000</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0_0_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0_0_0_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_1</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_2</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0_0_0</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_1</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_2</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_3</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_3_0</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq_3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq_4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp_1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp_2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp_3</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp_4</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_2</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1_2_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>payload</value></param>
</block>
<block>
<key>cdma_rx_hier</key>
<param><key>id</key><value>cdma_rx_hier_0</value></param>
<param><key>acq</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
</block>
<block>
<key>cdma_tx_hier</key>
<param><key>id</key><value>cdma_tx_hier_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0</value></param>
<param><key>attenuation</key><value>1.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>usb:1.4.5</value></param>
<param><key>frequency</key><value>249e7</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>samplerate</key><value>10e6</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0_0</value></param>
<param><key>attenuation</key><value>1.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>usb:1.5.5</value></param>
<param><key>frequency</key><value>249e7</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>samplerate</key><value>10e6</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0_0_0</value></param>
<param><key>attenuation</key><value>1.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>usb:1.6.5</value></param>
<param><key>frequency</key><value>249e7</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>samplerate</key><value>10e6</value></param>
</block>
<block>
<key>pluto_sink</key>
<param><key>id</key><value>pluto_sink_0_0_0_0</value></param>
<param><key>attenuation</key><value>1.0</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>cyclic</key><value>False</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>uri</key><value>usb:1.7.5</value></param>
<param><key>frequency</key><value>249e7</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>samplerate</key><value>10e6</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>usb:1.4.5</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>249e7</value></param>
<param><key>manual_gain</key><value>20</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>10e6</value></param>
<param><key>samplerate</key><value>10e6</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>249e7</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>11,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>12,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>output data 1</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>200e3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>13,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>outputdata 2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>200e3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>14,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>outbput data 3</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>200e3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.3</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0_0_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>15,0,1,4</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>outbput data 4</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>200e3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>update_time</key><value>0.3</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>stream_id</key><value>decoded_payload_bytes_1</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>1</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>1</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>Units</value></param>
</block>
<connection><source_block_id>blks2_error_rate_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0_0_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_tag_gate_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0_0_0</source_block_id><sink_block_id>blocks_tag_gate_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_1</source_block_id><sink_block_id>blocks_probe_freq_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_2</source_block_id><sink_block_id>blocks_probe_freq_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3</source_block_id><sink_block_id>blocks_probe_freq_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_3_0</source_block_id><sink_block_id>blocks_probe_freq_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>pluto_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0</source_block_id><sink_block_id>pluto_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0_0</source_block_id><sink_block_id>pluto_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0_0_0_0</source_block_id><sink_block_id>pluto_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_1</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_2</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1_2_0</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp_1</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp_2</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp_3</sink_block_id><source_key>10</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp_4</sink_block_id><source_key>11</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_2</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_3</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_4</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_1</sink_block_id><source_key>12</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_2</sink_block_id><source_key>13</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_3</sink_block_id><source_key>14</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_3_0</sink_block_id><source_key>15</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>decoded_header_1</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0_2</sink_block_id><source_key>decoded_header_2</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0_1</sink_block_id><source_key>decoded_header_3</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>decoded_header_4</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0_0_0_0_0</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0_0_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>cdma_rx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1_0</source_block_id><sink_block_id>blks2_error_rate_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
