<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.13'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>qt_cdma_txrx</value></param>
<param><key>author</key><value>Achilleas Anastasopoulos, Zhe Feng</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>qt_cdma_txrx</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>DataEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( 1.0-training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>DataEsN0dB_estimated</value></param>
<param><key>value</key><value>DataEsN0dB_est</value></param>
<param><key>gui_hint</key><value>9,0,1,2</value></param>
<param><key>label</key><value>DataEsN0dB_est</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>DataEsN0dBthreshold</value></param>
<param><key>value</key><value>10</value></param>
<param><key>gui_hint</key><value>5,0,1,3</value></param>
<param><key>label</key><value>DataEsN0dBthreshold</value></param>
<param><key>min_len</key><value>500</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>Es</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>EsN0dB</value></param>
<param><key>value</key><value>20</value></param>
<param><key>gui_hint</key><value>0,0,1,3</value></param>
<param><key>label</key><value>EsN0dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>80</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>EsN0dB_est</value></param>
<param><key>value</key><value>10*numpy.log10( cp.epsilon+ abs(Esest)/ (abs(N0est)+cp.epsilon) ) </value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>Esest</value></param>
<param><key>block_id</key><value>blocks_probe_signal_amp</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1e-2</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>N0</value></param>
<param><key>value</key><value>10**(-EsN0dB/10) * Es</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>N0est</value></param>
<param><key>block_id</key><value>blocks_probe_signal_n0</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>1.0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>TrainingEsN0dB</value></param>
<param><key>value</key><value>TrainingEsN0dB_est</value></param>
<param><key>gui_hint</key><value>8,0,1,2</value></param>
<param><key>label</key><value>TrainingEsN0dB_est</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>TrainingEsN0dB_est</value></param>
<param><key>value</key><value>EsN0dB_est + 10*numpy.log10( training_percent/100.0 ) </value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>acq_threshold_dB</value></param>
<param><key>value</key><value>-10</value></param>
<param><key>gui_hint</key><value>4,0,1,3</value></param>
<param><key>label</key><value>acq_threshold_dB</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-20</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chips_per_symbol</value></param>
<param><key>value</key><value>cp.chips_per_symbol</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>2,0,1,3</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>99</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>df</value></param>
<param><key>value</key><value>cp.df*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>df_Hz</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>1,0,1,3</value></param>
<param><key>label</key><value>df_Hz</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>(cp.freqs[0]*samp_rate)-1e-6</value></param>
<param><key>step</key><value>(cp.freqs[-1]-cp.freqs[0])*samp_rate/1000</value></param>
<param><key>stop</key><value>cp.freqs[-1]*samp_rate</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>dft</value></param>
<param><key>value</key><value>df</value></param>
<param><key>gui_hint</key><value>6,2,1,1</value></param>
<param><key>label</key><value>Deltaf (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>fmaxt</value></param>
<param><key>value</key><value>cp.freqs[-1]*samp_rate</value></param>
<param><key>gui_hint</key><value>6,1,1,1</value></param>
<param><key>label</key><value>f_max (Hz)</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>freq_acq_est</value></param>
<param><key>block_id</key><value>blocks_probe_freq</value></param>
<param><key>function_name</key><value>level</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>10</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>freq_est_acq</value></param>
<param><key>value</key><value>freq_acq_est</value></param>
<param><key>gui_hint</key><value>7,0,1,1</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,1,1,1</value></param>
<param><key>label0</key><value>'Auto'</value></param>
<param><key>label1</key><value>'Manual'</value></param>
<param><key>label</key><value>Manual/Auto</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>n_filt</value></param>
<param><key>value</key><value>cp.n_filt</value></param>
<param><key>gui_hint</key><value>6,0,1,1</value></param>
<param><key>label</key><value>n_filt</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff</value></param>
<param><key>value</key><value>onoff_auto if manual==0 else onoff_manual</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>onoff_auto</value></param>
<param><key>value</key><value>0 if DataEsN0dB_est&gt;DataEsN0dBthreshold else 1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>onoff_manual</value></param>
<param><key>value</key><value>0</value></param>
<param><key>gui_hint</key><value>3,0,1,1</value></param>
<param><key>label0</key><value>'Tracking'</value></param>
<param><key>label1</key><value>'Acquisition'</value></param>
<param><key>label</key><value>Manual Acq/Tra</value></param>
<param><key>num_opts</key><value>2</value></param>
<param><key>option0</key><value>0</value></param>
<param><key>option1</key><value>1</value></param>
<param><key>type</key><value>int</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload</value></param>
<param><key>value</key><value>map(int,numpy.random.randint(0,256,payload_bytes_per_frame))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>payload_bytes_per_frame</value></param>
<param><key>value</key><value>cp.payload_bytes_per_frame</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>symbol_rate*chips_per_symbol</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>symbol_rate</value></param>
<param><key>value</key><value>100e3</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>training_percent</value></param>
<param><key>value</key><value>cp.training_percent</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_static_text</value></param>
<param><key>value</key><value>'Acquisition' if onoff==1 else 'Tracking'</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>label</key><value>Ack/Tra Status</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_interleaved_char_to_complex</key>
<param><key>id</key><value>blocks_interleaved_char_to_complex_0_0</value></param>
<param><key>vector_input</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>Es**0.5</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1_0</value></param>
<param><key>const</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_amp</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>blocks_probe_signal_n0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>tagged_streams.make_lengthtags((payload_bytes_per_frame,), (0,), cp.length_tag_name)</value></param>
<param><key>vector</key><value>(1,1,1,1,1,1,1,1,1,1,1,1,1,1,1,0,0,0,0,0,1,1,1,1,1)</value></param>
</block>
<block>
<key>cdma_rx_hier</key>
<param><key>id</key><value>cdma_rx_hier_0</value></param>
<param><key>acq</key><value>onoff</value></param>
<param><key>acq_threshold_dB</key><value>acq_threshold_dB</value></param>
</block>
<block>
<key>cdma_tx_hier</key>
<param><key>id</key><value>cdma_tx_hier_0</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy ; numpy.random.seed(666)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import cdma.cdma_parameters as cp</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_1</value></param>
<param><key>import</key><value>from gnuradio.digital.utils import tagged_streams</value></param>
</block>
<block>
<key>pluto_source</key>
<param><key>id</key><value>pluto_source_0</value></param>
<param><key>bbdc</key><value>True</value></param>
<param><key>buffer_size</key><value>0x8000</value></param>
<param><key>uri</key><value>usb:1.6.5</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>auto_filter</key><value>True</value></param>
<param><key>filter</key><value></value></param>
<param><key>gain</key><value>"manual"</value></param>
<param><key>frequency</key><value>2420000000</value></param>
<param><key>manual_gain</key><value>20</value></param>
<param><key>quadrature</key><value>True</value></param>
<param><key>rfdc</key><value>True</value></param>
<param><key>bandwidth</key><value>4e5</value></param>
<param><key>samplerate</key><value>1e6</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>10e6</value></param>
<param><key>fc</key><value>249e7</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>14,0,1,4</value></param>
<param><key>name</key><value>Received Signal</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>label</key><value>Received Power</value></param>
<param><key>units</key><value>dBm</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>15,0,1,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Transmitted bits</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>13,0,1,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Spread</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>1e6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_1</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>gui_hint</key><value>11,0,1,4</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>Received bits</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>5e6</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>8e6</value></param>
<param><key>fc</key><value>249e7</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>gui_hint</key><value>12,0,1,4</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>bw0</key><value>5e6</value></param>
<param><key>center_freq0</key><value>249e7</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>5e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
<param><key>len_tag_name</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>bw0</key><value>5e6</value></param>
<param><key>center_freq0</key><value>2490000000</value></param>
<param><key>dc_offs_enb0</key><value>True</value></param>
<param><key>iq_imbal_enb0</key><value>True</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.3</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>5e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>pc_clock</value></param>
</block>
<connection><source_block_id>blocks_interleaved_char_to_complex_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleaved_char_to_complex_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1_0</source_block_id><sink_block_id>blocks_probe_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_1</source_block_id><sink_block_id>cdma_tx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_amp</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_probe_signal_n0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_rx_hier_0</source_block_id><sink_block_id>blocks_interleaved_char_to_complex_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>cdma_tx_hier_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>cdma_rx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pluto_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>cdma_rx_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
